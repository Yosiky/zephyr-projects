## course/15_command_parser/tests/command_parser/testcase.yaml
```yaml
tests:
  course.command_parser:
    platform_allow:
      - qemu_riscv64
    tags:
      - course
      - unit
```
